# Keil uVision project HOPE.uvprojx, settings and files
target HOPE (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HOPE +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\MALLOC;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\src;..\FWLIB\inc;..\HARDWARE\WS2812B;..\HARDWARE\Encoder;..\HARDWARE\ST7789;..\HARDWARE\DMA;..\HARDWARE\OLED;..\TEXT;..\HARDWARE\Hugo_UI;..\HARDWARE\Random;..\HARDWARE\FileSystem;..\HARDWARE\U8G2;..\HARDWARE\BEEPER;..\HARDWARE\MultiButton;..\HARDWARE\MPU6050;..\HARDWARE\QMC5883L;..\HARDWARE\I2C;..\HARDWARE\PCF8563;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP;..\HARDWARE\SHT30;..\HARDWARE\SDIO;..\HARDWARE\BMP280;..\HARDWARE\RC522;..\HARDWARE\LSM6DS3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../HARDWARE/W25QXX/: w25qxx.c w25qxx.h
    ../HARDWARE/WS2812B/: WS2812B.c WS2812B.h
    ../HARDWARE/Encoder/: Encoder.c Encoder.h
    ../HARDWARE/ST7789/: ST7789_Init.c ST7789_Init.h
    ../HARDWARE/DMA/: MyDMA.c MyDMA.h
    ../HARDWARE/OLED/: oled.c oled.h
    ../HARDWARE/BEEPER/: BEEPER.c BEEPER.h
    ../HARDWARE/Random/: Random.c Random.h
    ../HARDWARE/MultiButton/: multi_button.c multi_button.h multi_button_user.c multi_button_user.h
    ../HARDWARE/MPU6050/: inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050.c mpu6050.h myiic.c myiic.h
    ../HARDWARE/I2C/: myiic2.c myiic2.h
    ../HARDWARE/QMC5883L/: Ellipsoid fitting.c Ellipsoid fitting.h QMC5883L.c QMC5883L.h
    ../HARDWARE/PCF8563/: PCF8563.c PCF8563.h
    ../HARDWARE/SHT30/: SHT30.c SHT30.h
    ../HARDWARE/SDIO/: sdio_sdcard.c sdio_sdcard.h
    ../HARDWARE/BMP280/: BMP280.c BMP280.h
    ../HARDWARE/RC522/: RC522.c RC522.h
    ../HARDWARE/LSM6DS3/: lsm6ds3.c lsm6ds3.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/retarget/: retarget.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_sdio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_flash.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c
  group HugoUI
    ../HARDWARE/Hugo_UI/: Hugo_UI.c Hugo_UI.h HugoUI_BMP.c HugoUI_BMP.h HugoUI_User.c HugoUI_User.h
    ../HARDWARE/OLED/: OLED_User.c OLED_User.h
    ../HARDWARE/FileSystem/: FileSystem.c FileSystem.h
  group U8G2
    ../HARDWARE/U8G2/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_Init.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_a2printer.c u8x8_d_sh1107.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
